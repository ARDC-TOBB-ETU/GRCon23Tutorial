options:
  parameters:
    generate_options: qt_gui
    id: lab_wbfm_single_channel
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 32000*4*2*4
    value: 32000*4*2*4
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    comment: |-
      quadrature rate = samp_rate/4
      audio decimation = 2
    quad_rate: samp_rate/4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: sample rate = 32000
    samp_rate: '32000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      decimation = 4
      cutoff = samp_rate/2/4
      tran width = 20e3
    cutoff_freq: samp_rate/2/4
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: |-
      decimation = 4
      sample rate = samp_rate/4
      cutoff freq = samp_rate/4/2/4
      transition width = 1000
    cutoff_freq: samp_rate/4/2/4
    decim: '4'
    gain: '1'
    samp_rate: samp_rate/4
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 89.9e6
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', audio_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
