options:
  parameters:
    generate_options: qt_gui
    id: lab_wbfm_single_channel
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 32000*4*2*4
    value: 32000*4*2*4
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    comment: |-
      quadrature rate = samp_rate/4
      audio decimation = 2
    quad_rate: samp_rate/4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: sample rate = 32000
    samp_rate: '32000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      decimation = 4
      cutoff = samp_rate/2/4
      tran width = 20e3
    cutoff_freq: samp_rate/2/4
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: |-
      decimation = 4
      sample rate = samp_rate/4
      cutoff freq = samp_rate/4/2/4
      transition width = 1000
    cutoff_freq: samp_rate/4/2/4
    decim: '4'
    gain: '1'
    samp_rate: samp_rate/4
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 88e6
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: 88.0e6
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    devname: rtlsdr
    overall_gain0: '32'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [soapy_source_0, '0', low_pass_filter_0, '0']
- [soapy_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
