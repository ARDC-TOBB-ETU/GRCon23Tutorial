options:
  parameters:
    generate_options: qt_gui
    id: lab_wbfm_single_channel
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: g
  id: variable_qtgui_entry
  parameters:
    label: select gain
    type: real
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 32000*4*8
    value: 32000*4*8
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    comment: |-
      sample rate = samp_rate
      cutoff freq = samp_rate/2/4
      transition width = 20e3
    cutoff_freq: samp_rate/2/4
    gain: '1.0'
    samp_rate: samp_rate
    width: 20e3
    win: firdes.WIN_HAMMING
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    comment: |-
      quadrature rate = samp_rate/4
      audio decimation = 8
    quad_rate: samp_rate/4
  states: {}
- name: analog_wfm_rcv_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    comment: |-
      quadrature rate = samp_rate/4
      audio decimation = 8
    quad_rate: samp_rate/4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: sample rate = 32000
    samp_rate: '32000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: constant = g
    const: g
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: constant = 1 - g
    const: 1-g
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 200e3
    comment: |-
      decimation = 4
      taps = taps
    decim: '4'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      decimation = 4
      cutoff = samp_rate/2/4
      tran width = 20e3
    cutoff_freq: samp_rate/2/4
    decim: '4'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: baseband channel
  states: {}
- name: note_1
  id: note
  parameters:
    note: adjacent channel
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 88e6
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
